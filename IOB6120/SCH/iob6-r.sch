# EAGLE board iob6-r (EAGLE 4.09), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
MA10  (via drill 0.38) (continued)
  Top 0.178: 40.94,23.34 49.4,23.34 50.13,24.07 67.08,24.07 70.47,20.68 SBC.37 | 40.94,23.34 26.43,23.34 CF1.19 | IC1.25 6.27,79.62 6.27,85.52 25.55,85.52 IC2.11 v36.83,85.75 | IC5.11 84,85.48 83.96,85.45 79.04,85.45 78.78,85.18 66.36,85.18 66.05,85.48 65.82,85.48 IC4.11 63.65,85.48 62.93,85.48 62.4,84.95 60.34,84.95 60.22,85.06 57.4,85.06 56.98,85.48 46.77,85.48 IC3.11 v41.1,85.75 | 40.94,23.34 v40.94,23.42
  Bottom 0.178: v36.83,85.75 v41.1,85.75 40.94,85.41 v40.94,23.42
MA11  (via drill 0.38)
  Top 0.178: SBC.39 70.47,18.12 64.91,23.69 50.28,23.69 48.64,22.05 26.43,22.05 CF1.20 24.49,21.93 v23.88,21.93 | v17.67,80.87 16.07,80.87 16.07,79.96 16.14,79.88 16.14,79.62 IC1.45 | v21.29,84.49 25.55,84.49 IC2.12 27.72,84.23 37.33,84.23 37.67,83.88 40.64,83.88 40.94,84.19 44.56,84.19 44.6,84.23 IC3.12 46.77,84.23 47,84.23 47.35,83.88 59.69,83.88 59.99,84.19 63.61,84.19 63.65,84.23 IC4.12 65.82,84.23 66.05,84.23 66.4,83.88 78.74,83.88 79.04,84.19 84,84.19 IC5.12
  Bottom 0.178: v21.29,84.49 v17.67,80.87 17.82,80.53 17.82,27.99 v23.88,21.93
N$1  (via drill 0.38)
  Top 0.178: v108.31,53.98 108.92,53.98 IC12.66 | v114.59,48.56 114.86,48.83 121.41,48.83 127.36,42.89 IC13.2
  Route2 0.178: v108.31,53.98 109.18,53.98 v114.59,48.56
N$2  (via drill 0.38)
  Top 0.178: v60.34,29.44 61.06,29.44 62.09,30.47 IC14.7
  Bottom 0.178: v60.34,29.44 60.34,19.72 BATA.+
N$3  (via drill 0.38)
  Top 0.178: v118.52,65.52 110.21,65.52 108.23,67.5 103.31,67.5 103.28,67.54 IC7.10 | v118.52,74.93 116.12,77.33 R1.1
  Bottom 0.178: J3.3 116.42,62.51 118.36,64.45 118.36,65.37 v118.52,65.52 v118.52,74.93
N$4  (via drill 0.38)
  Top 0.178: v117.07,50.55 115.13,52.49 110.48,52.49 IC12.63 | v119.09,48.18 120.84,46.43 122.52,46.43 127.36,41.59 IC13.3
  Bottom 0.178: v117.07,50.55 119.09,48.53 v119.09,48.18
N$5  (via drill 0.38)
  Top 0.178: v120.76,49.86 120.5,49.59 114.86,49.59 113.98,50.47 110.48,50.47 IC12.59 | v122.48,44.75 126.9,40.34 127.36,40.34 IC13.4
  Bottom 0.178: v120.76,49.86 122.48,48.15 v122.48,44.75
N$6
  Top 0.178: IC12.56 110.48,49.1 111.77,49.1 111.89,49.21 124.69,49.21 130.02,43.88 130.02,39.04 129.34,39.04 IC13.5
N$7  (via drill 0.38)
  Top 0.178: v100.57,53.71 100.57,57.71 100.38,57.9 100.38,58.09 IC12.88 | v111.09,70.43 112.92,72.26 113.53,72.26 X1.P$3
  Route2 0.178: v100.57,53.71 100.84,53.71 102.02,54.89 104.46,54.89 v108.53,58.97
  Bottom 0.178: v108.53,58.97 110.06,60.49 111.09,60.49 v111.09,70.43
N$8
  Top 0.178: Q1.1 124.23,12.1 124.23,12.87 124.12,12.87 IC16.3
N$10  (via drill 0.38)
  Top 0.178: v115.01,45.67 114.13,46.55 110.48,46.55 IC12.51 | v115.39,47.12 118.63,43.88 121.68,43.88 126.67,38.89 126.67,37.78 127.36,37.78 IC13.6
  Bottom 0.178: v115.01,45.67 115.39,46.05 v115.39,47.12
N$11
  Top 0.178: IC12.34 106.9,36.91 106.9,36.49 109.91,36.49 111.81,38.39 116.5,38.39 117.37,39.27 119.16,39.27 119.74,39.84 119.74,42.13 119.01,42.13 JTAG.3
N$12  (via drill 0.38)
  Top 0.178: v121.07,33.78 120.92,33.63 105.91,33.63 105.91,36.91 IC12.32
  Bottom 0.178: v121.07,33.78 121.07,39.57 JTAG.6
N$13  (via drill 0.38)
  Top 0.178: v90.86,39.04 90.86,38.47 IC12.2 | v90.97,31.8 91.08,31.69 106.02,31.69 107.2,32.87 118.75,32.87 v119.01,32.6
  Bottom 0.178: v90.86,39.04 90.97,38.93 v90.97,31.8 | v119.01,32.6 120.19,33.78 120.19,41.4 120.92,42.13 JTAG.4
N$14  (via drill 0.38)
  Top 0.178: v84.46,38.28 86.86,40.68 87.39,40.68 87.46,40.6 87.69,40.6 IC12.142 | v85.83,27.04 86.06,26.81 89.03,26.81 91.69,24.14 91.69,22.66 100.8,22.66 101.87,21.59 101.87,20.29 v105.37,20.29
  Route2 0.178: v105.37,20.29 106.52,20.29 106.59,20.22 107.77,20.22 108.12,20.56 108.42,20.56 109.49,21.63 109.49,24.87 120.19,35.57 120.19,43.92 120.92,44.64 JTAG.2
  Bottom 0.178: v84.46,38.28 84.8,37.94 84.8,28.07 v85.83,27.04
N$15  (via drill 0.38)
  Top 0.178: v117.07,42.13 111.13,42.13 110.78,42.47 110.48,42.47 IC12.43 | v117.07,36.22 IC13.7
  Bottom 0.178: v117.07,42.13 116.8,41.86 116.8,36.49 v117.07,36.22
N$16  (via drill 0.38)
  Top 0.178: v114.13,44.64 111.51,44.64 111.47,44.6 110.48,44.6 IC12.47 | v115.39,36.22 116.31,35.31 127.32,35.31 127.36,35.27 IC13.8
  Bottom 0.178: v114.13,44.64 114.74,44.03 114.74,36.87 v115.39,36.22
N$17  (via drill 0.38)
  Top 0.178: v113.72,39.5 112.15,39.5 111.7,39.95 110.48,39.95 IC12.38 | v115.39,34.28 115.54,34.43 121.56,34.43 122.1,33.9 127.36,33.9 IC13.9
  Bottom 0.178: v113.72,39.5 114.36,38.85 114.36,35.31 v115.39,34.28
N$18  (via drill 0.38)
  Top 0.178: v103.85,36.33 103.85,36.91 IC12.28 | v107.47,32.22 107.85,31.84 114.86,31.84 115.13,31.57 129.26,31.57 130.48,32.79 130.48,38.16 127.2,38.16 127.05,38.32 127.05,39.42 129.45,39.42 129.64,39.61 129.64,43.54 129.34,43.54 IC13.1
  Bottom 0.178: v103.85,36.33 106.06,36.33 106.06,33.63 v107.47,32.22
N$19  (via drill 0.38)
  Top 0.178: v93.33,35.08 93.33,36.91 IC12.7 | v95.58,30.12 96.34,29.36 106.17,29.36 107.32,28.22 125.57,28.22 130.59,23.19 IC15.3
  Bottom 0.178: v93.33,35.08 93.18,34.93 93.18,32.64 94.32,31.5 95.58,31.5 v95.58,30.12
N$20  (via drill 0.38)
  Top 0.178: v101.75,45.1 96.53,45.1 95.35,43.92 91.54,43.92 91.54,40.87 91.92,40.49 93.29,40.49 94.21,39.57 94.78,39.57 94.78,38.47 IC12.10 | v111.05,31.19 111.58,30.66 126.06,30.66 130.98,25.74 IC15.1
  Route2 0.178: v101.75,45.1 103.28,45.1 104.08,44.3 104.38,44.3 107.66,41.02 107.66,39.76 109.79,37.63 109.79,32.45 v111.05,31.19
N$21  (via drill 0.38)
  Top 0.178: v81.41,38.96 85.41,42.96 87.69,42.96 IC12.137 | v80.42,7.76 80.68,7.49 95.05,7.49 95.43,7.87 129.26,7.87 129.68,8.29 135.13,8.29 136.73,9.89 IC17.10
  Bottom 0.178: v81.41,38.96 80.42,37.97 v80.42,7.76
N$22  (via drill 0.38)
  Top 0.178: v122.78,57.75 122.33,58.2 120.08,58.2 117.49,60.8 114.48,60.8 112.23,63.04 104.8,63.04 103.58,61.82 98.9,61.82 98.9,59.65 IC12.91 | v126.75,15.61 130.59,11.76 IC17.4
  Bottom 0.178: v122.78,57.75 124.54,55.99 124.54,17.82 v126.75,15.61
N$23  (via drill 0.38)
  Top 0.178: v79.81,49.97 80.19,49.97 80.65,50.43 85.14,50.43 85.67,50.97 87.69,50.97 IC12.121 | v80.26,40.14 80.26,27.69 102.4,27.69 102.59,27.5 118.52,27.5 118.86,27.84 123.39,27.84 v125.18,26.05 | v129.3,15.61 130.59,14.31 IC17.2
  Bottom 0.178: v79.81,49.97 80.26,49.52 v80.26,40.14 | v125.18,26.05 129.3,21.93 v129.3,15.61
N$24  (via drill 0.38)
  Top 0.178: v101.75,46.39 92.72,46.39 89.94,43.61 89.26,43.61 IC12.136 | v112.88,37.74 113.75,36.87 v123.77,36.87 | v126.14,13.67 130.59,9.21 IC17.6
  Route2 0.178: v101.75,46.39 102.51,46.39 104.23,44.68 104.53,44.68 108.08,41.14 109.49,41.14 v112.88,37.74
  Bottom 0.178: v123.77,36.87 124.16,36.49 124.16,15.65 v126.14,13.67
N$25  (via drill 0.38)
  Top 0.178: v74.59,37.02 74.66,37.02 74.66,42.28 82.05,49.67 87.39,49.67 87.46,49.59 87.69,49.59 IC12.124 | v95.62,7.15 129.53,7.15 129.68,7 136.39,7 136.73,7.34 IC17.8
  Route2 0.178: v74.59,37.02 74.59,36.49 83.81,27.27 83.81,20.03 86.09,17.74 86.09,11.95 86.63,11.42 86.63,11 87.66,9.97 88.07,9.97 89.14,8.9 89.14,8.48 90.47,7.15 v95.62,7.15
N$26  (via drill 0.38)
  Top 0.178: v142.75,40.03 141.64,41.14 139.4,41.14 IC13.18
  Bottom 0.178: v142.75,40.03 143.47,39.31 143.47,28.03 145.76,25.74 LPT.9
N$27  (via drill 0.38)
  Top 0.178: v141,40.49 139.55,40.49 139.4,40.34 IC13.17
  Bottom 0.178: v141,40.49 141.76,40.49 143.85,42.58 147.13,42.58 147.13,29.25 146.37,28.49 LPT.8
N$28  (via drill 0.38)
  Top 0.178: v144.12,36.56 141.3,36.56 139.4,38.47 IC13.16
  Bottom 0.178: v144.12,36.56 145.03,35.65 145.03,31.95 145.76,31.23 LPT.7
N$29
  Top 0.178: IC13.15 137.41,37.17 137.41,36.83 137.3,36.83 137.11,36.64 137.11,33.06 145.34,33.06 LPT.6
N$30
  Top 0.178: IC13.14 139.4,35.92 145.34,35.92 LPT.5
N$31
  Top 0.178: IC13.13 139.4,34.96 146.52,34.96 147.13,35.57 147.13,38.05 146.41,38.05 LPT.4
N$32  (via drill 0.38)
  Top 0.178: v139.89,34.32 139.74,34.32 139.4,33.97 IC13.12
  Bottom 0.178: v139.89,34.32 142.1,36.53 142.1,40.3 143.05,41.25 145.34,41.25 LPT.3
N$33
  Top 0.178: IC13.11 137.41,32.68 136.96,32.68 136.73,32.91 136.73,39.38 143.01,39.38 145.03,41.4 145.03,43.99 145.34,43.99 LPT.2
N$34  (via drill 0.38)
  Top 0.178: IC15.2 132.58,24.45 132.96,24.83 132.96,28.14 132.08,28.14 131.78,28.45 R9.1 131.78,30.01 v132.99,31.23
  Bottom 0.178: v132.99,31.23 132.99,33.55 145.76,46.32 LPT.1
N$35
  Top 0.178: 135.45,24.85 135.62,25.02 135.62,28.45 R10.1 | 135.45,24.85 132.54,21.93 IC15.4 | LPT.16 148.31,39.42 148.31,38.47 148.2,38.47 147.51,37.78 147.51,31.53 145.61,31.53 138.86,24.79 135.51,24.79 135.45,24.85
N$36
  Top 0.178: IC17.11 138.71,11.76 139.93,12.98 140.84,12.98 145.91,18.05 147.09,18.05 148.84,19.8 149.03,19.8 149.64,20.41 149.64,42.2 148.96,42.2 LPT.15
N$37
  Top 0.178: IC17.3 132.58,13.02 132.92,13.36 140.69,13.36 145.76,18.43 146.52,18.43 147.13,19.04 147.13,21.48 146.37,21.48 LPT.10
N$38
  Top 0.178: IC17.1 132.58,14.96 132.88,14.66 136.58,14.66 136.61,14.62 140.81,14.62 145.34,19.15 LPT.11
N$39
  Top 0.178: IC17.5 132.58,10.46 132.96,10.85 139.78,10.85 145.34,16.41 LPT.12
N$40
  Top 0.178: IC17.9 138.71,9.21 143.13,13.63 145.34,13.63 LPT.13
N$41  (via drill 0.38)
  Top 0.178: v76.91,26.85 76.91,41.25 82.93,47.27 84.65,47.27 85.33,46.58 87.69,46.58 IC12.130
  Route2 0.178: v76.91,26.85 81.83,21.93 IO1.26
N$42  (via drill 0.38)
  Top 0.178: v89.87,49.63 89.52,49.97 89.26,49.97 IC12.123
  Route2 0.178: v89.87,49.63 89.87,48.98 87.77,46.89 87.77,39.54 v87.12,38.89
  Bottom 0.178: v87.12,38.89 87.12,27.08 86.17,26.12 86.17,23.08 85.45,22.35 IO1.24
N$43  (via drill 0.38)
  Top 0.178: v89.87,41.48 89.26,41.48 IC12.140
  Bottom 0.178: v89.87,41.48 88.49,40.11 88.49,24.79 88.68,24.6 88.68,23.08 87.96,22.35 IO1.22
N$44  (via drill 0.38)
  Top 0.178: v80.15,52.72 80.42,52.98 86.25,52.98 86.47,52.76 87.31,52.76 87.46,52.6 87.69,52.6 IC12.118 | v79.12,23.72 80.19,22.66 88.72,22.66 89.45,21.93 IO1.20
  Bottom 0.178: v80.15,52.72 79.12,51.69 v79.12,23.72
N$45  (via drill 0.38)
  Top 0.178: v102.86,53.71 105.94,56.79 106.78,56.79 106.78,58.09 IC12.75 | v102.4,43.92 101.9,43.42 97.07,43.42 v96.42,42.77
  Route2 0.178: v92.68,39.04 v96.42,42.77
  Bottom 0.178: v102.86,53.71 102.4,53.25 v102.4,43.92 | v92.68,39.04 92.68,26.81 92.53,26.66 92.53,25.44 91.69,24.6 91.69,23.08 92.42,22.35 IO1.18
N$46  (via drill 0.38)
  Top 0.178: v117.45,40.94 116.92,41.48 110.48,41.48 IC12.41 | v116.12,16.68 115.7,16.26 95.96,16.26 v95.73,16.03
  Bottom 0.178: v117.45,40.94 117.64,40.75 117.64,39.15 118.36,38.43 118.36,18.92 v116.12,16.68 | v95.73,16.03 95.58,16.18 95.58,20.87 IO1.16
N$47  (via drill 0.38)
  Top 0.178: v97.18,48.3 98.74,49.86 106.59,49.86 106.71,49.97 108.92,49.97 IC12.58
  Route2 0.178: v97.18,48.3 97.18,47.04 99.5,44.72 99.5,43.23 98.86,42.58 98.86,42.51 96.04,39.69 95.77,39.69 95.31,39.23 95.31,35.76 93.18,33.63 93.18,29.02 96.99,25.21 98.25,25.21 98.86,24.6 98.86,23.08 98.13,22.35 IO1.14
N$48  (via drill 0.38)
  Top 0.178: v101.52,60.26 101.41,60.26 101.41,59.65 IC12.86
  Route2 0.178: v104.08,68.15 104.5,68.15 114.06,58.59 114.06,55.84 119.74,50.17 119.74,35.65 111.58,27.5 109.83,27.5 106.48,24.14 106.48,23.69 105.45,22.66 101.83,22.66 101.1,21.93 IO1.12
  Bottom 0.178: v101.52,60.26 101.79,60.53 101.79,61.82 103.77,63.8 103.77,67.84 v104.08,68.15
N$49  (via drill 0.38)
  Top 0.178: v100.65,39.19 100.76,39.19 100.76,38.47 IC12.22
  Bottom 0.178: v100.65,39.19 102.55,37.29 102.55,28.75 101.87,28.07 101.87,23.08 102.59,22.35 IO1.10
N$50  (via drill 0.38)
  Top 0.178: v104.61,35.5 104.61,36.49 104.38,36.72 104.38,36.91 IC12.29
  Bottom 0.178: v104.61,35.5 104.72,35.38 104.72,24.94 104.38,24.6 104.38,23.08 105.11,22.35 IO1.8
N$51  (via drill 0.38)
  Top 0.178: v111.47,45.48 110.97,45.97 110.48,45.97 IC12.50 | v117.72,22.69 117.68,22.66 109.45,22.66 108.72,21.93 IO1.6
  Route2 0.178: v111.47,45.48 112.88,44.07 112.92,44.07 113.45,43.54 113.45,42.43 v117.45,38.43
  Bottom 0.178: v117.45,38.43 117.72,38.16 v117.72,22.69
N$52
  Top 0.178: R6.1 143.05,42.85 145.57,45.36 147.89,45.36 LPT.14
N$53  (via drill 0.38)
  Top 0.178: v114.1,42.85 115.66,42.85 115.66,45.94 114.67,46.93 112.88,46.93 111.85,47.96 110.48,47.96 IC12.54
  Route2 0.178: v112.34,25.86 112.34,24.98 111.54,24.18 111.54,23.08 110.82,22.35 IO1.4
  Bottom 0.178: v114.1,42.85 113.07,41.82 113.07,38.85 112.23,38.01 112.23,25.97 v112.34,25.86
N$54
  Top 0.178: IC12.134 87.69,44.6 87.46,44.6 87.39,44.68 82.97,44.68 79.24,40.94 79.24,24.9 82.28,24.9 IO1.25
N$55  (via drill 0.38)
  Top 0.178: v84.3,54.7 84.46,54.55 87.69,54.55 IC12.114
  Route2 0.178: v84.3,54.7 84.3,53.25 83.73,52.68 83.73,42.66 85.1,41.29 85.1,24.9 IO1.23
N$56  (via drill 0.38)
  Top 0.178: v87.12,41.97 87.69,41.97 IC12.139
  Bottom 0.178: v87.12,41.97 87.77,41.33 87.77,24.9 IO1.21
N$57  (via drill 0.38)
  Top 0.178: v90.02,53.48 89.26,53.48 IC12.116
  Route2 0.178: v90.02,50.77 90.02,50.39 90.51,49.9 90.51,49.1 89.22,47.8 v89.22,38.77
  Bottom 0.178: v90.02,50.77 v90.02,53.48 | v89.22,38.77 89.79,38.2 89.79,24.79 IO1.19
N$58  (via drill 0.38)
  Top 0.178: v121.18,53.33 116.23,58.28 114.44,58.28 110.71,62.01 107.2,62.01 107.2,59.99 107.28,59.92 107.28,59.65 IC12.74 | v123.13,27.19 119.28,23.34 113.79,23.34 113.53,23.08 94.25,23.08 93.48,23.84 IO1.17
  Bottom 0.178: v121.18,53.33 123.13,51.38 v123.13,27.19
N$59  (via drill 0.38)
  Top 0.178: v95.96,49.48 99.47,52.98 108.92,52.98 IC12.64 | v91.5,27.04 94.06,24.49 94.55,24.49 IO1.15
  Route2 0.178: v95.96,49.48 95.96,48.95 96.34,48.56 96.34,46.51 v90.17,40.34
  Bottom 0.178: v90.17,40.34 90.17,28.37 v91.5,27.04
N$60  (via drill 0.38)
  Top 0.178: v102.25,42.77 102.93,42.09 108.92,42.09 IC12.42
  Route2 0.178: v102.25,42.77 102.25,42.24 98.97,38.96 98.97,35.88 v95.43,32.33
  Bottom 0.178: v95.43,32.33 97.68,32.33 97.68,24.9 IO1.13
N$61  (via drill 0.38)
  Top 0.178: v101.71,53.67 102.1,54.05 102.29,54.05 102.29,58.09 IC12.84 | v93.18,26.39 93.68,25.9 98.21,25.9 99.62,24.49 IO1.11
  Route2 0.178: v98.86,44.45 98.86,44.34 97.07,42.55 97.07,42.51 96.34,41.78 95.96,41.78 94.48,40.3 94.48,38.77 90.25,34.54 90.25,29.32 v93.18,26.39
  Bottom 0.178: v101.71,53.67 98.86,50.81 v98.86,44.45
N$62  (via drill 0.38)
  Top 0.178: v105.07,62.4 105.07,61.56 104,60.49 102.9,60.49 102.9,59.65 IC12.83 | v86.47,32.91 89.45,29.93 94.86,29.93 95.81,28.98 102.02,28.98 v102.86,28.14
  Route2 0.178: v105.07,62.4 105.07,62.59 102.4,65.25 93.26,65.25 86.36,58.36 86.36,54.78 84.19,52.6 84.19,47.73 86.47,45.44 v86.47,32.91
  Bottom 0.178: v102.86,28.14 102.86,24.9 IO1.9
N$63  (via drill 0.38)
  Top 0.178: v112.42,40.14 111.58,40.98 110.48,40.98 IC12.40
  Route2 0.178: v112.42,40.14 112.42,39.12 113.53,38.01 113.53,32.75 107.51,26.73 v107.47,26.73
  Bottom 0.178: v107.47,26.73 105.75,25.02 105.75,24.9 IO1.7
N$64  (via drill 0.38)
  Top 0.178: v108.31,44.68 108.61,44.98 108.92,44.98 IC12.48
  Bottom 0.178: v108.31,44.68 108.95,44.03 108.95,25.59 108.27,24.9 IO1.5
N$65  (via drill 0.38)
  Top 0.178: v119.58,51.23 117.34,53.48 110.48,53.48 IC12.65 | v119.13,27.19 117.14,25.21 111.96,25.21 111.24,24.49 IO1.3
  Bottom 0.178: v119.58,51.23 120.12,50.7 120.12,45.02 121.26,43.88 122.29,43.88 122.29,35.38 121.72,34.81 121.72,29.78 v119.13,27.19
N$66  (via drill 0.38)
  Top 0.178: v95.54,34.85 95.77,34.85 95.77,36.91 IC12.12 | v94.4,33.93 94.02,33.55 86.21,33.55 v81.41,28.75
  Bottom 0.178: v95.54,34.85 94.63,33.93 v94.4,33.93 | v81.41,28.75 80.8,28.14 80.8,11.15 82.28,9.66 IO2.26
N$67  (via drill 0.38)
  Top 0.178: v83.81,32.72 86.55,35.46 92.27,35.46 92.27,36.91 IC12.5
  Bottom 0.178: v83.81,32.72 83.81,20.03 84.07,19.76 84.07,10.39 84.8,9.66 IO2.24
N$68  (via drill 0.38)
  Top 0.178: v140.42,71.31 139.36,70.24 R11.2
  Bottom 0.178: v140.42,71.31 140.42,89.71 144.54,93.83 VGA.1
N$69  (via drill 0.38)
  Top 0.178: v142.1,70.7 141.61,70.21 R12.2
  Bottom 0.178: v142.1,70.7 142.1,89.1 144.54,91.54 VGA.2
N$70  (via drill 0.38)
  Top 0.178: R13.2 v143.51,70.82
  Bottom 0.178: v143.51,70.82 143.51,88.23 144.54,89.26 VGA.3
N$71  (via drill 0.38)
  Top 0.178: v89.14,36.6 91.27,36.6 91.27,36.91 IC12.3
  Bottom 0.178: v89.14,36.6 89.14,10.85 87.96,9.66 IO2.22
N$72  (via drill 0.38)
  Top 0.178: v95.12,42.77 95.12,41.33 96.3,40.14 99.35,40.14 99.35,39.04 99.77,38.62 99.77,38.47 IC12.20
  Route2 0.178: v95.12,42.77 95.12,42.39 89.79,37.06 89.79,34.62 86.47,31.31 86.47,14.12 89.14,11.46 89.14,10.43 89.9,9.66 IO2.20
N$73  (via drill 0.38)
  Top 0.178: v79.96,59.61 80.3,59.96 92.76,59.96 92.76,59.65 IC12.103 | v79.31,9.78 81.22,7.87 91.27,7.87 92,8.6 IO2.18
  Bottom 0.178: v79.96,59.61 78.24,57.9 78.24,10.85 v79.31,9.78
N$74  (via drill 0.38)
  Top 0.178: v76.3,63.77 77.41,64.87 98.63,64.87 98.63,62.51 98.4,62.28 97.9,62.28 97.9,59.65 IC12.93 | v81.9,5.36 v88.15,5.36
  Bottom 0.178: v76.3,63.77 75.65,63.12 75.65,47.12 75.88,46.89 75.88,12.64 78.66,9.86 78.66,8.6 v81.9,5.36 | v88.15,5.36 94.55,5.36 94.55,8.6 IO2.16
N$75  (via drill 0.38)
  Top 0.178: v76.3,60.99 76.38,60.91 94.28,60.91 94.28,59.65 IC12.100 | v77.56,13.25 78.32,12.48 85.56,12.48 86.63,11.42 86.63,9.97 96.3,9.97 97.07,9.21 IO2.14
  Bottom 0.178: v76.3,60.99 76.26,60.95 76.26,26.2 77.56,24.9 v77.56,13.25
N$76  (via drill 0.38)
  Top 0.178: v129.79,59.5 129.95,59.5 130.29,59.16 IC11.16
  Bottom 0.178: v129.79,59.5 131.2,60.91 131.2,74.89 130.94,75.16 130.94,95.39 129.76,96.57 SER1.6
N$77  (via drill 0.38)
  Top 0.178: v85.48,63.88 85.86,63.5 94.67,63.5 95.89,62.28 97.26,62.28 97.26,59.65 IC12.94 | v80.91,41.71 79.62,40.41 79.62,26.16 v87.12,26.16
  Route2 0.178: v87.12,26.16 89.14,24.14 89.14,21.17 97.83,12.48 98.29,12.48 99.31,11.46 99.31,10.39 100.04,9.66 IO2.12
  Bottom 0.178: v85.48,63.88 84.26,62.66 84.26,55.58 82.97,54.28 82.97,47.23 81.56,45.82 81.56,42.35 v80.91,41.71
N$78  (via drill 0.38)
  Top 0.178: v98.29,36.33 99.28,36.33 99.28,36.91 IC12.19 | v103.2,32.56 v101.87,33.9
  Bottom 0.178: v98.29,36.33 100.23,36.33 100.23,36.07 101.07,35.23 101.87,35.23 v101.87,33.9 | v103.2,32.56 104,31.76 104,18.85 104.61,18.24 104.61,12.1 103.92,11.42 103.92,10.39 103.2,9.66 IO2.10
N$79  (via drill 0.38)
  Top 0.178: v96.04,39.04 96.27,39.04 96.27,38.47 IC12.13 | v93.83,32.91 93.26,32.33 v92.04,32.33 | v91.31,10.69 91.66,10.35 98.82,10.35 99.2,9.97 103.92,9.97 104.69,9.21 IO2.8
  Bottom 0.178: v96.04,39.04 95.01,38.01 95.01,35.46 93.75,34.2 93.75,32.98 v93.83,32.91 | v92.04,32.33 92.15,32.22 92.15,25.59 91.31,24.75 v91.31,10.69
N$80  (via drill 0.38)
  Top 0.178: v104.08,45.75 94.44,45.75 92.99,44.3 91.16,44.3 91.16,40.72 91.77,40.11 91.77,38.47 IC12.4
  Route2 0.178: v104.08,45.75 110.82,45.75 111.2,46.13 111.73,46.13 116.8,41.06 116.8,39.99 118.1,38.7 118.1,34.93 v115.39,32.22
  Bottom 0.178: v115.39,32.22 112.99,29.82 112.99,25.59 112.61,25.21 111.93,25.21 111.93,14.35 109.03,11.46 109.03,10.43 108.27,9.66 IO2.6
N$81  (via drill 0.38)
  Top 0.178: v92.04,34.2 92.04,34.7 92.76,35.42 92.76,36.91 IC12.6
  Route2 0.178: v92.04,34.2 92.04,33.25 92.8,32.49 92.8,28.11 96.76,24.14 96.76,20.75 101.26,16.26 107.2,16.26 111.54,11.91 111.54,10.39 110.82,9.66 IO2.4
N$82
  Top 0.178: Q1.2 122.21,12.1 122.21,12.87 122.29,12.87 IC16.2
N$83  (via drill 0.61)
  other vias: 120.68,6.38
N$85  (via drill 0.61)
  other vias: 125.76,6.38
N$86  (via drill 0.38)
  Top 0.178: v85.71,55.19 85.79,55.12 87.69,55.12 IC12.113 | v85.75,32.03 89.45,28.33 v98.32,28.33
  Bottom 0.178: v85.71,55.19 83.43,52.91 83.43,43.04 85.18,41.29 85.18,32.6 v85.75,32.03 | v98.32,28.33 100.42,26.24 101.49,26.24 101.49,18.08 CPREQ.2
N$90
  Top 0.178: 25.82,62.17 26.12,62.17 IC10.8 | 25.82,62.17 22.66,62.17 21.97,62.85 IC10.6 19.99,63.46 12.83,63.46 11.95,64.34 SPKR.+ | IC10.11 28.11,65.37 28.11,65.02 28.26,65.02 28.41,64.87 28.41,63.77 26.01,63.77 25.82,63.58 25.82,62.17
N$91
  Top 0.178: IC10.3 21.97,67.27 23.53,68.83 29.93,68.83 30.09,68.68 31.8,68.68 32.98,69.86 43.5,69.86 44.72,71.08 52.37,71.08 IC9.1
N$92  (via drill 0.38)
  Top 0.178: v98.21,42.77 100.08,40.91 101.3,40.91 101.3,38.47 IC12.23 | v94.67,50.01 v89.87,54.81 | v87.77,69.52 88.04,69.79 97.79,69.79 100.46,67.12 108.08,67.12 110.48,64.72 v117.72,64.72 | v119.39,63.42 119.85,62.97 120.23,62.97 IC11.6
  Route2 0.178: v117.72,64.72 118.1,64.72 v119.39,63.42
  Bottom 0.178: v98.21,42.77 94.67,46.32 v94.67,50.01 | v89.87,54.81 87.81,52.76 86.47,52.76 86.47,68.22 v87.77,69.52
N$93  (via drill 0.38)
  Top 0.178: v100.3,32.33 98.51,34.12 95.35,34.12 95.12,34.35 94.89,34.35 94.89,35.12 95.28,35.5 95.28,36.91 IC12.11 | v101.9,30.66 102.55,30.01 v125.79,30.01 | v126.4,63.27 122.59,63.27 122.21,63.65 IC11.5
  Bottom 0.178: v100.3,32.33 101.9,30.73 v101.9,30.66 | v125.79,30.01 126.06,30.28 126.06,61.44 126.4,61.79 v126.4,63.27
N$94  (via drill 0.38)
  Top 0.178: v105.37,32.33 104.72,32.33 103.58,33.48 102.82,33.48 102.82,36.91 IC12.26 | v107.47,28.98 v125.18,28.98 | v125.11,65.21 122.21,65.21 IC11.4
  Bottom 0.178: v105.37,32.33 107.47,30.24 v107.47,28.98 | v125.18,28.98 125.15,29.02 125.15,61.75 125.11,61.79 v125.11,65.21
N$95  (via drill 0.38)
  Top 0.178: v103.35,46.77 104.72,46.77 104.72,45.48 104.34,45.1 102.67,45.1 101.37,43.8 95.77,43.8 95.77,42.51 97.56,40.72 99.73,40.72 99.73,39.19 100.27,38.66 100.27,38.47 IC12.21 | v106.67,62.4 111.96,62.4 v113.14,61.21 | v117.98,61.21 118.4,60.8 128.69,60.8 128.99,61.1 130.29,61.1 IC11.18
  Route2 0.178: v103.35,46.77 103.35,50.17 103.01,50.51 103.01,51.12 107.66,55.77 107.66,57.18 109.18,58.7 109.18,59.88 v106.67,62.4
  Bottom 0.178: v113.14,61.21 v117.98,61.21
N$96  (via drill 0.38)
  Top 0.178: v103.47,35.19 103.2,35.19 103.2,36.6 103.28,36.68 103.28,36.91 IC12.27 | v104.08,33.9 104.72,33.25 120.69,33.25 120.88,33.06 v129.83,33.06 | v129.15,65.75 129.64,66.24 130.29,66.24 IC11.22
  Bottom 0.178: v103.47,35.19 104.08,34.58 v104.08,33.9 | v129.83,33.06 129.15,33.74 v129.15,65.75
N$97  (via drill 0.38)
  Top 0.178: v82.97,57.02 82.97,55.12 84.04,54.05 87.69,54.05 IC12.115 | v117.03,62.2 117.18,62.05 124.84,62.05 125.49,62.7 126.06,62.7 126.14,62.62 130.29,62.62 IC11.19
  Route2 0.178: v82.97,57.02 82.97,60.45 88.61,66.09 88.61,66.59 92.99,70.97 93.29,70.97 96.04,73.71 96.04,73.98 96.42,74.36 104.88,74.36 v117.03,62.2
N$101
  Top 0.178: IC11.10 120.23,57.29 119.85,56.91 119.85,55.65 122.33,55.65 124.99,52.98 C16.1
N$102
  Top 0.178: IC11.12 121.83,54.74 121.83,52.98 C16.2
N$103
  Top 0.178: IC11.13 132.27,54.74 133.72,54.74 C12.1
N$104
  Top 0.178: IC11.14 132.27,56.6 132.38,56.72 133.72,56.72 C12.2
N$105
  Top 0.178: IC11.11 122.21,56.03 124.19,56.03 127.28,52.95 C15.2
N$106
  Top 0.178: R4.1 14.88,59.92 11.38,63.42 6.35,63.42 5.44,64.34 SPKR.-
N$107
  Top 0.178: IC11.15 130.29,57.9 129.15,59.04 129.15,60.72 133.76,60.72 C11.1
N$110  (via drill 0.38)
  Top 0.178: v125.76,62.05 125.37,61.67 122.21,61.67 IC11.7
  Bottom 0.178: v125.76,62.05 125.76,83.43 126.75,84.42 SER2.3
N$112  (via drill 0.38)
  Top 0.178: v126.4,70.17 125.6,70.17 122.21,66.78 IC11.3
  Bottom 0.178: v126.4,70.17 126.59,70.36 126.59,74.85 SER3.3
N$113  (via drill 0.38)
  Top 0.178: v130.56,69.9 130.56,69.33 IC11.24
  Bottom 0.178: v130.56,69.9 130.56,93.18 129.72,94.02 SER1.5
N$114  (via drill 0.38)
  Top 0.178: v129.68,68.64 130.29,68.03 IC11.23
  Bottom 0.178: v129.68,68.64 128,70.32 128,93.22 127.2,94.02 SER1.3
R0  (via drill 0.38)
  Top 0.178: v94.97,60.26 94.89,60.26 94.89,59.65 IC12.99 | v101.52,62.47 102.48,63.42 v118.25,63.42 | v119.66,65.75 119.77,65.86 127.89,65.86 128.77,64.99 129.3,64.99 130.18,65.86 136.54,65.86 137.8,67.12 R11.1
  Route2 0.178: v94.97,60.26 95.2,60.26 97.41,62.47 v101.52,62.47
  Bottom 0.178: v118.25,63.42 119.66,64.83 v119.66,65.75
RAM0_L  (via drill 0.38)
  Top 0.178: v69.06,77.25 79.58,77.25 82.89,73.94 IC6.15 | v60.6,85.6 59.58,85.6 IC3.22
  Route2 0.178: v69.06,77.25 68.95,77.25 v60.6,85.6
RAM1_L  (via drill 0.38)
  Top 0.178: v55.46,70.74 73.25,70.74 74.55,72.03 84.65,72.03 84.99,71.69 IC6.13 | v37.9,85.1 38.28,85.48 38.35,85.48 IC2.22
  Route2 0.178: v55.46,70.74 53.63,70.74 39.27,85.1 v37.9,85.1
RAM2_L  (via drill 0.38)
  Top 0.178: v88.72,68.87 86.97,68.87 IC6.11 | v88.72,85.14 89.07,85.48 96.8,85.48 IC5.22
  Bottom 0.178: v88.72,68.87 v88.72,85.14
RAM3_L  (via drill 0.38)
  Top 0.178: v89.37,86.13 89.18,86.32 79.43,86.32 79.12,86.02 78.63,86.02 IC4.22 | IC6.9 v89.26,66.32
  Bottom 0.178: v89.26,66.32 89.37,66.43 v89.37,86.13
RD_SR_L  (via drill 0.38)
  Top 0.178: v106.13,57.52 105.91,57.52 105.91,58.09 IC12.77 | v95.31,61.94 94.13,63.12 75.5,63.12 74.09,64.53 72.57,64.53 71.84,63.8 SBC.3
  Route2 0.178: v103.77,61.18 103.77,63.35 102.25,64.87 98.59,64.87 95.66,61.94 v95.31,61.94
  Bottom 0.178: v106.13,57.52 103.77,59.88 v103.77,61.18
READ_L  (via drill 0.38)
  Top 0.178: v105.71,61.44 105.64,61.37 105.41,61.37 105.41,59.65 IC12.78 | v100.34,86.59 98.93,88 IC5.24 96.8,88.57 96.49,88.87 79.43,88.87 79.12,88.57 78.63,88.57 IC4.24 76.45,88.53 76.38,88.61 66.21,88.61 65.94,88.87 60.38,88.87 60.07,88.57 59.58,88.57 IC3.24 57.4,88.53 56.64,88.53 56.3,88.87 44.49,88.87 44.22,88.61 40.56,88.61 40.53,88.57 IC2.24 38.35,88.53 38.28,88.61 28.11,88.61 27.76,88.95 v6.96,88.95 | v7.76,77.44 7.76,78.05 IC1.28 | v12.29,72.91 16.68,68.53 19.99,68.53 IC10.2 | CF1.9 24.49,36.03 23.34,36.03 v14.5,44.87 14.85,45.02 15.27,45.44 20.64,45.44 28.56,53.37 SBC.11
  Bottom 0.178: v105.71,61.44 105.71,65.33 104.72,66.32 104.72,79.96 100.34,84.34 v100.34,86.59 | v14.5,44.87 12.45,46.93 12.45,72.57 v12.29,72.91 v7.76,77.44 7.84,77.79 7.84,88.07 v6.96,88.95
RTC_RST  (via drill 0.38)
  Top 0.178: v83.62,55.84 85.98,55.84 86.21,55.61 87.69,55.61 IC12.112 | v81.56,47.12 81.56,46.43 75.88,40.75 75.88,21.59 79.81,21.59 81.22,20.18 v98.25,20.18 | v105.26,18.2 105.52,18.47 114.71,18.47 117.45,21.21 123.85,21.21 124.84,20.22 IC16.5
  Route2 0.178: v98.25,20.18 99.77,20.18 101.14,18.81 104.65,18.81 v105.26,18.2
  Bottom 0.178: v83.62,55.84 81.56,53.78 v81.56,47.12
RTS2  (via drill 0.38)
  Top 0.178: v132.84,65.21 132.27,65.21 IC11.21
  Bottom 0.178: v132.84,65.21 137.99,60.07 137.99,57.37 138.67,56.68 HS2.2
S$2
  Bottom 0.178: 27.69,29.82 27.65,29.86
SKIP_L  (via drill 0.38)
  Top 0.178: v106.13,60.26 106.29,60.26 106.29,59.65 IC12.76 | v91.62,61.56 90.86,62.32 72.87,62.32 71.84,61.29 SBC.5
  Route2 0.178: v106.13,60.26 105.75,60.26 104.72,59.23 93.94,59.23 v91.62,61.56
SPKR  (via drill 0.38)
  Top 0.178: IC10.5 19.99,64.72 19.99,65.37 IC10.4 21.97,65.37 25.78,65.37 | IC10.9 28.11,63.39 28.56,63.39 28.79,63.61 28.79,66.66 28.11,66.66 IC10.12 | 25.78,65.37 25.78,66.66 26.12,66.66 IC10.12 | 25.78,65.37 25.78,65.06 26.12,64.72 IC10.10 | v94.17,61.6 94.48,61.29 96.76,61.29 96.76,59.65 IC12.95 | v93.41,74.85 90.55,77.71 69.52,77.71 69.33,77.9 60.64,77.9 58.62,75.88 v34.89,75.88 | v33.25,69.22 32.33,68.3 28.11,68.3 IC10.13 26.16,67.92 26.16,67.27 IC10.12
  Bottom 0.178: v94.17,61.6 93.9,61.86 93.9,74.36 v93.41,74.85 | v34.89,75.88 33.25,74.24 v33.25,69.22
STATUS_L  (via drill 0.38)
  Top 0.178: v82.05,67.61 80.84,67.61 IC6.7 | v87.54,70.66 89.18,72.3 96.19,72.3 97.33,73.44 97.33,73.9 | 97.33,73.9 97.33,75.16 96.08,75.16 IC7.1 | IC7.15 101.1,73.9 97.33,73.9
  Bottom 0.178: v82.05,67.61 85.1,70.66 v87.54,70.66
TX0  (via drill 0.38)
  Top 0.178: v122.67,68.38 122.56,68.38 122.21,68.03 IC11.2 | v124.19,79.35 129.26,84.42 SER2.5
  Bottom 0.178: v122.67,68.38 122.78,68.49 122.78,77.94 v124.19,79.35
TX1  (via drill 0.38)
  Top 0.178: v128.65,70.82 123.74,70.82 122.21,69.29 IC11.1
  Bottom 0.178: v128.65,70.82 129.15,71.31 129.15,74.85 SER3.5
TX2  (via drill 0.38)
  Top 0.178: v123.93,63.92 130.29,63.92 IC11.20
  Bottom 0.178: v123.93,63.92 124.08,64.07 124.08,73.83 125.37,75.12 125.37,84.57 125.91,85.1 125.91,95.89 126.59,96.57 SER1.4
VBAT2  (via drill 0.38)
  Top 0.178: v59.54,31.38 59.42,31.38 59.04,31 IC14.2 | v64.57,22.96 70.7,16.83 72.26,16.83 72.68,16.41 88.76,16.41 89.03,16.68 103.89,16.68 104.53,17.32 120.31,17.32 121.03,18.05 IC16.8
  Bottom 0.178: BATB.+ 59.54,42.39 v59.54,31.38 59.69,31.04 60.99,29.74 60.99,26.54 v64.57,22.96
VCC_NV  (via drill 0.38)
  Top 0.254: v81.67,69.1 80.84,69.1 IC6.6 | v84.42,74.63 84.68,74.89 84.99,74.89 IC6.16 86.97,74.89 89.03,74.89 C9.1 | v79.24,98.44 78.63,98.44 IC4.32 | v95.35,98.44 96.8,98.44 IC5.32 | v43.12,98.32 40.53,98.32 IC2.32 | v47.38,98.32 57.4,98.32 IC3.32 | 51.57,75.16 62.97,75.16 63.31,75.5 C6.1 | 51.57,75.16 31.12,75.16 30.73,75.54 C5.1 | v50.89,65.9 50.36,65.9 50.28,65.82 C14.1 | v51.57,73.75 51.57,75.16 | v52.83,35.65 53.56,35.65 56.91,32.3 IC14.1
  Bottom 0.254: v81.67,69.1 84.42,71.84 v84.42,74.63 84.26,74.97 84.26,93.41 | 84.26,93.41 v79.24,98.44 78.89,98.29 74.74,94.13 51.54,94.13 51.42,94.09 | v95.35,98.44 90.36,93.45 84.38,93.45 84.26,93.41 | v43.12,98.32 v47.38,98.32 47.54,97.98 51.42,94.09 | v52.83,35.65 51,37.48 51,65.56 v50.89,65.9 51.57,66.59 v51.57,73.75 51.42,74.09 51.42,94.09
VCCO  (via drill 0.38, 0.41, 0.61)
  Top 0.254: 119.16,81.92 119.16,81.64 119.43,81.64 | 108.92,56.03 IC12.70 108.92,56.18 108.92,56.22 | 108.92,56.53 IC12.71 108.92,56.41 108.92,56.22 | JTAG.5 117.94,39.99 117.53,39.99 116.34,38.81 108.31,38.81 107.96,38.47 IC12.36 107.7,36.91 107.47,36.91 IC12.35 107.47,38.47 v107.47,39.04 | IC12.1 90.21,38.47 90.21,38.74 89.48,39.46 89.26,39.46 IC12.144 87.81,39.42 87.81,38.2 v85.83,38.2 | IC12.107 90.7,58.13 90.47,58.13 IC12.108 90.25,58.09 90.25,57.52 v90.21,57.52 | v97.18,39.12 97.29,39.12 97.83,38.58 97.83,38.47 IC12.16 | v107.39,47.73 108.57,47.73 108.72,47.57 108.92,47.57 IC12.53 | v90.74,48.26 89.64,48.26 89.45,48.07 89.26,48.07 IC12.127 | v89.87,55.99 89.26,55.99 IC12.111 | v99.01,56.52 99.01,57.63 99.31,57.94 99.31,58.09 IC12.90 | v108.31,56.22 108.92,56.22
  Top 0.61: REG3.3.6 119.43,83.21 119.43,83.19 | v119.43,80.42 119.43,81.64 119.43,83.19 | C2.+ 114.35,92 114.35,91.72 | REG2.5.4 102.86,81.92 104.67,81.92 104.67,83.21 | 104.67,83.21 REG2.5.3 | 104.67,83.21 105.21,83.74 105.21,86.46 106.5,87.02 106.76,87.99 106.76,88.25 C3.1 108.27,90.04 110.9,90.04 112.67,91.82 114.25,91.82 114.35,91.72 | 114.35,91.72 115.85,90.22 116.92,90.22 119.43,87.71 119.43,83.19 | REG3.3.5 116.95,81.92 119.16,81.92 119.38,81.92
  Bottom 0.254: 107.16,56.39 107.05,56.11 107.32,56.11 107.7,56.22 v108.31,56.22 108.65,56.07 110.32,56.07 111.73,54.66 111.73,54.13 111.24,53.63 111.24,48.3 111.58,47.96 C102.1 | 91.14,40.16 90.93,39.84 | 90.89,48.22 91.14,48.22 v90.74,48.26 90.4,48.22 86.7,48.22 C104.1 85.83,47.19 v85.83,38.2 | 107.32,47.84 107.47,47.84 | 97.18,40.16 v97.18,39.12 97.03,38.77 97.03,35.84 C101.1 | 107.32,47.73 v107.39,47.73 | 91.14,55.99 v89.87,55.99 | v90.21,57.52 90.89,56.83 91.14,56.52 | C107.1 99.01,60.8 v99.01,56.52 | v107.47,39.04 107.47,39.76 107.32,40.16
  Bottom 0.61: v119.43,80.42 117.65,78.64 117.65,65.86 116.13,64.34 112.37,64.34 112.27,64.24 112.27,59.94 111.33,59 109.78,59 107.16,56.39
  Bottom 0.813: 91.19,56.52 v99.01,56.52 107.32,56.52 107.32,56.11 107.32,47.84 107.32,47.73 107.32,40.16 97.18,40.16 91.14,40.16 91.14,48.22 91.14,55.99 91.14,56.52
VS  (via drill 0.38)
  Top 0.178: v93.41,57.52 93.41,58.09 IC12.102 | v101.98,64.22 102.13,64.07 119.62,64.07 120.12,64.57 144.04,64.57 148.96,69.48 148.96,75.62 149,75.62 150.86,77.48 150.86,86.97 150.18,86.97 VGA.14
  Bottom 0.178: v93.41,57.52 94.32,58.43 94.32,60.53 95.08,61.29 95.96,61.29 95.96,62.24 95.31,62.89 95.31,63.42 96.11,64.22 v101.98,64.22
WR_SR_L
  Top 0.178: IC12.101 93.79,59.65 93.79,60.34 74.47,60.34 74.13,59.99 70.7,59.99 70.17,60.53 70.17,62.55 72.3,62.55 72.99,63.23 SBC.4
WRITE_L  (via drill 0.38)
  Top 0.178: v12.75,99.39 12.75,98.82 IC1.11 | v31.04,96.15 32.52,94.67 38.35,94.67 IC2.29 40.53,94.89 40.87,95.24 46.89,95.24 47.19,94.93 57.37,94.93 57.4,94.89 IC3.29 59.58,94.89 59.8,94.89 60.15,95.24 65.94,95.24 66.24,94.93 76.42,94.93 76.45,94.89 IC4.29 78.63,94.89 78.85,94.89 79.2,95.24 79.31,95.24 | 79.31,95.24 96.49,95.24 96.8,94.93 IC5.29 | v100.88,36.33 100.23,35.69 97.41,35.69 97.41,36.91 IC12.15 | v101.1,42.77 102.21,41.67 105.41,41.67 105.71,41.36 105.71,39.69 108.69,39.69 108.76,39.61 108.92,39.61 IC12.37 | v68.57,35.19 67.12,33.74 60.19,33.74 57.59,36.33 52.57,36.33 49.1,32.87 26.43,32.87 CF1.36 | v84.84,52.34 84.57,52.07 72.8,52.07 71.84,51.12 SBC.13 | v79.31,94.97 79.31,95.24
  Route2 0.178: v100.88,36.33 100.88,36.68 103.09,38.89 103.09,40.18 105.11,42.2 105.11,43.04 104.23,43.92 103.31,43.92 102.67,44.56 102.13,44.56 101.73,44.16 | 101.73,44.16 101.1,43.54 v101.1,42.77 | v84.84,52.34 85.79,51.38 87.39,51.38 87.43,51.42 94.97,51.42 97.83,48.56 97.83,48.07 101.68,44.22 101.73,44.16
  Bottom 0.178: v12.75,99.39 14.12,99.39 14.12,99.66 14.5,100.04 29.59,100.04 29.59,97.6 v31.04,96.15 | v68.57,35.19 69.79,36.41 69.79,49.06 70.85,50.13 SBC.13 70.82,51.5 68.95,53.37 68.95,66.89 69.71,67.65 69.71,85.37 v79.31,94.97

## Text on the board
Top: Top | L1
Route2: Layer 2 | L2
$GND: Layer 3 | L3
Bottom: Bottom | L4
tPlace: Top Silk | 2 | 0 | 1 | -VT | CTS | -INIT | RTS
bPlace: Bot. Silk
tStop: Top Mask
bStop: Bot. Mask
Document: Material: FR2 | Thickness: 0.062" | Copper: 1 oz
_tplace: 2 | 2 | 6 | 6 | 1 | 1 | 11 | 11 | 1 | 1 | Female | Female | 10 | 10 | 2 | 2 | 1 | 1 | 5 | 5 | 10 | 10 | 10 | 10 | 15 | 15 | 2 | 2 | 1 | 1 | 10 | 10 | 6 | 6 | 3 | 3 | 1 | 1 | 2 | 2 | 1 | 1 | 2 | 2 | 8 | 8 | 5 | 5 | 3 | 3 | 2 | 2 | 1 | 1 | 14 | 14 | 1 | 1 | F25 | F25 | 1 | 1 | Lithium 3V | Lithium 3V | 1 | 1 | - | - | + | + | 6 | 6 | 50 | 50 | 1 | 1 | Lithium 3V | Lithium 3V | 26 | 26 | - | - | + | + | 1 | 1 | 13 | 13 | 25 | 25 | 26 | 26 | 2,54 | 2,54